# Keil uVision project C_Board_Standard_Robot.uvprojx, settings and files
target C_Board_Standard_Robot (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: C_Board_Standard_Robot +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Application;../Bsp;../Components;../Components/Algorithm;../Components/Controller;../Components/Devices;../Components/Algorithm/Include;../Communication;../Controller;../modules/CAN_receive;../modules/Dual_board;../modules/referee;../modules/remote_control;../modules/super_cap;../Robots;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../modules/PC_task;../support
  asm include: ..\Inc;../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group Application/User
    ../Src/: main.c gpio.c freertos.c can.c dma.c spi.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/Applications
    ../Application/: ins_task.c chassis.c gimbal.c helm.c shoot.c referee_usart_task.c referee_usart_task.h chassis_power_control.c chassis_power_control.h
  group Application/Bsp
    ../Bsp/: bsp_dwt.c bsp_PWM.c bsp_can.c bsp_rc.c bsp_uart.c bsp_fric.c bsp_fric.h bsp_usb.c bsp_usb.h bsp_usart.c bsp_usart.h ui.c ui.h ui_default_Ungroup_0.c ui_default_Ungroup_0.h ui_default_Ungroup_1.c ui_default_Ungroup_1.h ui_default_Ungroup_2.c ui_default_Ungroup_2.h ui_default_Ungroup_3.c ui_default_Ungroup_3.h ui_default_Ungroup_4.c ui_default_Ungroup_4.h ui_default_Ungroup_5.c ui_default_Ungroup_5.h ui_interface.c ui_interface.h ui_types.h
  group Application/Components
    ../Components/Devices/: BMI088driver.c BMI088Middleware.c
    ../Components/: kalman_filter.c user_lib.c
    ../Components/Controller/: controller.c
    ../Components/Algorithm/: QuaternionEKF.c
  group modules
    ../modules/CAN_receive/: CAN_receive.c
    ../modules/Dual_board/: Dual_board.c
    ../modules/referee/: referee.c
    ../modules/remote_control/: remote_control.c
    ../modules/super_cap/: super_cap.c
    ../modules/PC_task/: PC_task.c PC_task.h
  group Robots
    ../Robots/: robots.c
  group Communication
    ../Communication/: broadcast.c pub_sub.c
  group controller
    ../Controller/: pid.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group support
    ../support/: CRC8_CRC16.c fifo.c mem_mang4.c CRC8_CRC16.h fifo.h linux_list.h macro_mutex.h mem_mang.h
software components: CMSIS:CORE 4.3.0
